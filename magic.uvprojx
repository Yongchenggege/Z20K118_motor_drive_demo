# Keil uVision project magic.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: magic +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEV_Z20K118M
  c include: .\User;.\Platform\Core;.\StdDriver\Inc;.\APP\pwm;.\APP\led;.\APP\uart;.\APP\delay;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\Platform\Devices\Z20K118M\MakeRule\ARMC\Z20K118M_flash.scf
  link misc: --entry=Reset_Handler
  group User
    ./User/: Z20K118M_startup.s main.c Z20K118_conf.h
  group APP
    ./APP/led/: led.c
    ./APP/pwm/: pwm.c
    ./APP/uart/: uart.c
    ./APP/delay/: delay.c
    ./APP/: drv10970.c enconder.c
  group StdDriver
    ./StdDriver/Src/: Z20K11xM_gpio.c Z20K11xM_clock.c Z20K11xM_tim.c Z20K11xM_uart.c Z20K11xM_drv.c Z20K11xM_sysctrl.c Z20K11xM_wdog.c Z20K11xM_stim.c
